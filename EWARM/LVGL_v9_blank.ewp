# IAR project LVGL_v9_blank.ewp, settings and files
configuration LVGL_v9_blank (ARM, debug)
  General.OGChipSelectEditMenu: STM32F429IG ST STM32F429IG
  General.RTConfigPath2: $TOOLKIT_DIR$\inc\c\DLib_Config_Full.h
  General.CoreVariant: 39
  General.FPU2: 4
  ICCARM.CCDefines: USE_HAL_DRIVER; STM32F429xx
  ICCARM.CCIncludePath2: ../Core/Inc; ../Drivers/STM32F4xx_HAL_Driver/Inc; ../Drivers/STM32F4xx_HAL_Driver/Inc/Legacy; ../Drivers/CMSIS/Device/ST/STM32F4xx/Include; ../Drivers/CMSIS/Include; ..\lvgls; ..\lvgls\lvgl; ..\lvgls\lvgl\src; ..\lvgls\lvgl\src\core
  ICCARM.CCOptLevel: 3
  ICCARM.CCOptStrategy: 2
  ICCARM.IccLang: 0
  OBJCOPY.OOCOutputFile: LVGL_v9_blank.hex
  ILINK.IlinkOutputFile: LVGL_v9_blank.out
  ILINK.IlinkIcfFile: stm32f429xx_flash.icf
  ILINK.IlinkProgramEntryLabel: __iar_program_start
  group Application/EWARM
    ./: startup_stm32f429xx.s
  group Application/User/Core
    ../Core/Src/: 24cxx.c ctiic.c delay.c ft5206.c gpio.c gt9xxx.c key.c lcd.c led.c ltdc.c main.c myiic.c sdram.c stm32f4xx_hal_msp.c stm32f4xx_it.c sys.c tim.c touch.c usart.c
  group Drivers/CMSIS
    ../Core/Src/: system_stm32f4xx.c
  group Drivers/STM32F4xx_HAL_Driver
    ../Drivers/STM32F4xx_HAL_Driver/Src/: stm32f4xx_hal.c stm32f4xx_hal_cortex.c stm32f4xx_hal_dma.c stm32f4xx_hal_dma2d.c stm32f4xx_hal_dma_ex.c stm32f4xx_hal_exti.c stm32f4xx_hal_flash.c stm32f4xx_hal_flash_ex.c stm32f4xx_hal_flash_ramfunc.c stm32f4xx_hal_gpio.c stm32f4xx_hal_ltdc.c stm32f4xx_hal_ltdc_ex.c stm32f4xx_hal_pwr.c stm32f4xx_hal_pwr_ex.c stm32f4xx_hal_rcc.c stm32f4xx_hal_rcc_ex.c stm32f4xx_hal_sdram.c stm32f4xx_hal_sram.c stm32f4xx_hal_tim.c stm32f4xx_hal_tim_ex.c stm32f4xx_hal_uart.c stm32f4xx_ll_dma2d.c stm32f4xx_ll_fmc.c
  group lvgls/core
    ../lvgls/lvgl/src/core/: lv_group.c lv_obj.c lv_obj_class.c lv_obj_draw.c lv_obj_event.c lv_obj_id_builtin.c lv_obj_pos.c lv_obj_property.c lv_obj_scroll.c lv_obj_style.c lv_obj_style_gen.c lv_obj_tree.c lv_refr.c
  group lvgls/display
    ../lvgls/lvgl/src/display/: lv_display.c
  group lvgls/draw
    ../lvgls/lvgl/src/draw/: lv_draw.c lv_draw_arc.c lv_draw_buf.c lv_draw_image.c lv_draw_label.c lv_draw_line.c lv_draw_mask.c lv_draw_rect.c lv_draw_triangle.c lv_draw_vector.c lv_image_decoder.c
    ../lvgls/lvgl/src/draw/vg_lite/: lv_draw_buf_vg_lite.c lv_draw_vg_lite.c lv_draw_vg_lite_arc.c lv_draw_vg_lite_border.c lv_draw_vg_lite_box_shadow.c lv_draw_vg_lite_fill.c lv_draw_vg_lite_img.c lv_draw_vg_lite_label.c lv_draw_vg_lite_layer.c lv_draw_vg_lite_line.c lv_draw_vg_lite_mask_rect.c lv_draw_vg_lite_triangle.c lv_draw_vg_lite_vector.c lv_vg_lite_decoder.c lv_vg_lite_grad.c lv_vg_lite_math.c lv_vg_lite_path.c lv_vg_lite_pending.c lv_vg_lite_stroke.c lv_vg_lite_utils.c
    ../lvgls/lvgl/src/draw/sw/: lv_draw_sw.c lv_draw_sw_arc.c lv_draw_sw_border.c lv_draw_sw_box_shadow.c lv_draw_sw_fill.c lv_draw_sw_gradient.c lv_draw_sw_img.c lv_draw_sw_letter.c lv_draw_sw_line.c lv_draw_sw_mask.c lv_draw_sw_mask_rect.c lv_draw_sw_transform.c lv_draw_sw_triangle.c lv_draw_sw_vector.c
    ../lvgls/lvgl/src/draw/sw/blend/: lv_draw_sw_blend.c lv_draw_sw_blend_to_al88.c lv_draw_sw_blend_to_argb8888.c lv_draw_sw_blend_to_i1.c lv_draw_sw_blend_to_l8.c lv_draw_sw_blend_to_rgb565.c lv_draw_sw_blend_to_rgb888.c
  group lvgls/font
    ../lvgls/lvgl/src/font/: lv_binfont_loader.c lv_font.c lv_font_dejavu_16_persian_hebrew.c lv_font_fmt_txt.c lv_font_montserrat_10.c lv_font_montserrat_12.c lv_font_montserrat_14.c lv_font_montserrat_16.c lv_font_montserrat_18.c lv_font_montserrat_20.c lv_font_montserrat_22.c lv_font_montserrat_24.c lv_font_montserrat_26.c lv_font_montserrat_28.c lv_font_montserrat_28_compressed.c lv_font_montserrat_30.c lv_font_montserrat_32.c lv_font_montserrat_34.c lv_font_montserrat_36.c lv_font_montserrat_38.c lv_font_montserrat_40.c lv_font_montserrat_42.c lv_font_montserrat_44.c lv_font_montserrat_46.c lv_font_montserrat_48.c lv_font_montserrat_8.c lv_font_simsun_14_cjk.c lv_font_simsun_16_cjk.c lv_font_unscii_16.c lv_font_unscii_8.c
  group lvgls/indev
    ../lvgls/lvgl/src/indev/: lv_indev.c lv_indev_scroll.c
  group lvgls/layouts
    ../lvgls/lvgl/src/layouts/flex/: lv_flex.c
    ../lvgls/lvgl/src/layouts/grid/: lv_grid.c
    ../lvgls/lvgl/src/layouts/: lv_layout.c
  group lvgls/libs
    ../lvgls/lvgl/src/libs/barcode/: code128.c lv_barcode.c
    ../lvgls/lvgl/src/libs/bin_decoder/: lv_bin_decoder.c
    ../lvgls/lvgl/src/libs/bmp/: lv_bmp.c
    ../lvgls/lvgl/src/libs/ffmpeg/: lv_ffmpeg.c
    ../lvgls/lvgl/src/libs/freetype/: lv_freetype.c lv_freetype_glyph.c lv_freetype_image.c lv_freetype_outline.c lv_ftsystem.c
    ../lvgls/lvgl/src/libs/fsdrv/: lv_fs_cbfs.c lv_fs_fatfs.c lv_fs_littlefs.c lv_fs_memfs.c lv_fs_posix.c lv_fs_stdio.c lv_fs_win32.c
  group lvgls/lv_src
    ../lvgls/lvgl/src/: lv_init.c
  group lvgls/misc
    ../lvgls/lvgl/src/misc/: lv_anim.c lv_anim_timeline.c lv_area.c lv_array.c lv_async.c lv_bidi.c lv_color.c lv_color_op.c lv_event.c lv_fs.c lv_ll.c lv_log.c lv_lru.c lv_math.c lv_matrix.c lv_palette.c lv_profiler_builtin.c lv_rb.c lv_style.c lv_style_gen.c lv_templ.c lv_text.c lv_text_ap.c lv_timer.c lv_utils.c
    ../lvgls/lvgl/src/misc/cache/: lv_cache.c lv_cache_entry.c lv_cache_lru_rb.c lv_image_cache.c lv_image_header_cache.c
  group lvgls/osal
    ../lvgls/lvgl/src/osal/: lv_cmsis_rtos2.c lv_freertos.c lv_mqx.c lv_os.c lv_os_none.c lv_pthread.c lv_rtthread.c lv_windows.c
  group lvgls/others
    ../lvgls/lvgl/src/others/file_explorer/: lv_file_explorer.c
    ../lvgls/lvgl/src/others/fragment/: lv_fragment.c lv_fragment_manager.c
    ../lvgls/lvgl/src/others/gridnav/: lv_gridnav.c
    ../lvgls/lvgl/src/others/ime/: lv_ime_pinyin.c
    ../lvgls/lvgl/src/others/imgfont/: lv_imgfont.c
    ../lvgls/lvgl/src/others/monkey/: lv_monkey.c
    ../lvgls/lvgl/src/others/observer/: lv_observer.c
    ../lvgls/lvgl/src/others/snapshot/: lv_snapshot.c
    ../lvgls/lvgl/src/others/sysmon/: lv_sysmon.c
    ../lvgls/lvgl/src/others/vg_lite_tvg/: vg_lite_matrix.c
  group lvgls/porting
    ../lvgls/: lv_conf.h lv_port_disp.c lv_port_indev.c
  group lvgls/stdlib
    ../lvgls/lvgl/src/stdlib/: lv_mem.c
    ../lvgls/lvgl/src/stdlib/builtin/: lv_mem_core_builtin.c lv_sprintf_builtin.c lv_string_builtin.c lv_tlsf.c
    ../lvgls/lvgl/src/stdlib/clib/: lv_mem_core_clib.c lv_sprintf_clib.c lv_string_clib.c
    ../lvgls/lvgl/src/stdlib/micropython/: lv_mem_core_micropython.c
    ../lvgls/lvgl/src/stdlib/rtthread/: lv_mem_core_rtthread.c lv_sprintf_rtthread.c lv_string_rtthread.c
  group lvgls/themes
    ../lvgls/lvgl/src/themes/: lv_theme.c
    ../lvgls/lvgl/src/themes/default/: lv_theme_default.c
    ../lvgls/lvgl/src/themes/mono/: lv_theme_mono.c
    ../lvgls/lvgl/src/themes/simple/: lv_theme_simple.c
  group lvgls/tick
    ../lvgls/lvgl/src/tick/: lv_tick.c
  group lvgls/widgets
    ../lvgls/lvgl/src/widgets/animimage/: lv_animimage.c
    ../lvgls/lvgl/src/widgets/arc/: lv_arc.c
    ../lvgls/lvgl/src/widgets/bar/: lv_bar.c
    ../lvgls/lvgl/src/widgets/button/: lv_button.c
    ../lvgls/lvgl/src/widgets/buttonmatrix/: lv_buttonmatrix.c
    ../lvgls/lvgl/src/widgets/calendar/: lv_calendar.c lv_calendar_chinese.c lv_calendar_header_arrow.c lv_calendar_header_dropdown.c
    ../lvgls/lvgl/src/widgets/canvas/: lv_canvas.c
    ../lvgls/lvgl/src/widgets/chart/: lv_chart.c
    ../lvgls/lvgl/src/widgets/checkbox/: lv_checkbox.c
    ../lvgls/lvgl/src/widgets/dropdown/: lv_dropdown.c
    ../lvgls/lvgl/src/widgets/property/: lv_dropdown_properties.c lv_image_properties.c lv_keyboard_properties.c lv_label_properties.c lv_obj_properties.c lv_roller_properties.c lv_style_properties.c lv_textarea_properties.c
    ../lvgls/lvgl/src/widgets/image/: lv_image.c
    ../lvgls/lvgl/src/widgets/imagebutton/: lv_imagebutton.c
    ../lvgls/lvgl/src/widgets/keyboard/: lv_keyboard.c
    ../lvgls/lvgl/src/widgets/label/: lv_label.c
    ../lvgls/lvgl/src/widgets/led/: lv_led.c
    ../lvgls/lvgl/src/widgets/line/: lv_line.c
    ../lvgls/lvgl/src/widgets/list/: lv_list.c
    ../lvgls/lvgl/src/widgets/lottie/: lv_lottie.c
    ../lvgls/lvgl/src/widgets/menu/: lv_menu.c
    ../lvgls/lvgl/src/widgets/msgbox/: lv_msgbox.c
    ../lvgls/lvgl/src/widgets/objx_templ/: lv_objx_templ.c
    ../lvgls/lvgl/src/widgets/roller/: lv_roller.c
    ../lvgls/lvgl/src/widgets/scale/: lv_scale.c
    ../lvgls/lvgl/src/widgets/slider/: lv_slider.c
    ../lvgls/lvgl/src/widgets/span/: lv_span.c
    ../lvgls/lvgl/src/widgets/spinbox/: lv_spinbox.c
    ../lvgls/lvgl/src/widgets/spinner/: lv_spinner.c
    ../lvgls/lvgl/src/widgets/switch/: lv_switch.c
    ../lvgls/lvgl/src/widgets/table/: lv_table.c
    ../lvgls/lvgl/src/widgets/tabview/: lv_tabview.c
    ../lvgls/lvgl/src/widgets/textarea/: lv_textarea.c
    ../lvgls/lvgl/src/widgets/tileview/: lv_tileview.c
    ../lvgls/lvgl/src/widgets/win/: lv_win.c
