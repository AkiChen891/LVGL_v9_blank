<?xml version="1.0" encoding="UTF-8"?>
<workspace>
  <project>
    <path>$WS_DIR$\LVGL_v9_blank.ewp</path>
  </project>
  <batchBuild />
</workspace>
